<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\koki_rtos_LoRaWAN.ewp</path>
  </project>
  <batchBuild />
</workspace>
